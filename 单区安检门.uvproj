# Keil uVision project 单区安检门.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 单区安检门 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\MAIN;.\delay;.\HARDWARE\AIP650;.\HARDWARE\GUI;.\HARDWARE\PWM;.\HARDWARE\EEPROM;.\HARDWARE\ADC;.\HARDWARE\UART;.\HARDWARE\IR
  group main
    ./MAIN/: main.c
    ./delay/: delay.c
  group HARDWARE
    ./HARDWARE/AIP650/: AIP650.c
    ./HARDWARE/PWM/: PWM.c
    ./HARDWARE/EEPROM/: EEPROM.c
    ./HARDWARE/GUI/: GUI.c
    ./HARDWARE/ADC/: ADC.c
    ./HARDWARE/UART/: uart.c uart.h
    ./HARDWARE/IR/: IR.c IR.h
